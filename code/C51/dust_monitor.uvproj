# Keil uVision project dust_monitor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dust_monitor +hex
  c flags: Optimize=8 SizeSpeed=1
  group dust_monitor
    ./: STARTUP.A51 main.c delay.c lcd.c key.c key.h lcd.h
